# Keil uVision project FreeRTOS_Demo.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Demo
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\STM32F10x_FWLib\inc;..\Drive;..\Drive\led;..\Drive\usart;..\System\sys;..\System\delay;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\Libraries\CMSIS\Include;..\FreeRTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\FreeModbus\modbus\include;..\FreeModbus\port;..\FreeModbus\modbus\rtu;..\FreeModbus\modbus\ascii;..\FreeModbus\modbus\tcp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group StarUp
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group STM32_LIB
    ../Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group FreeRTOS/Source
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group User
    ./: main.c
  group System
    ../System/sys/: sys.c
  group Drive
    ../Drive/: bsp_init.c
    ../Drive/led/: bsp_led.c
  group FreeModbus\modbus\functions
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group FreeModbus\modbus\rtu
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/: mb.c
  group FreeModbus\port
    ../FreeModbus/port/: portevent.c portserial.c porttimer.c port.c
software components: CMSIS:CORE 4.3.0
